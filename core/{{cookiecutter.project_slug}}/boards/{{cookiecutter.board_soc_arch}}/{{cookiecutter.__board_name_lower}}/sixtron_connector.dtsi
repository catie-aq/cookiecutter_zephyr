/*
 * Copyright (c) {{cookiecutter.copyright_year}} {{cookiecutter.copyright_holder}}
 * SPDX-License-Identifier: Apache-2.0
 */

#include <zephyr/dt-bindings/gpio/sixtron-header.h>

/ {
    sixtron_connector_1: sixtron-connector-1 {
        compatible = "sixtron-bus";
        #gpio-cells = <2>;
        gpio-map-mask = <0xffffffff 0xffffffc0>;
        gpio-map-pass-thru = <0 0x3f>;
        gpio-map = <CAN_RX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <CAN_TX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <I2C_SCL 0 &GPIO_PORT PIN_NUMBER 0>,
                   <I2C_SDA 0 &GPIO_PORT PIN_NUMBER 0>,
                   <UART_RX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <UART_TX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_MOSI 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_MISO 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_SCK 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_SS 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ICAPT 0 &GPIO_PORT PIN_NUMBER 0>,
                   <WKUP 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO4 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC4 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DAC 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO5 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO6 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO7 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO8 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO9 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO10 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO11 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO12 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO13 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO14 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO15 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO16 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO17 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO18 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO19 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO20 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO21 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO22 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO23 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO24 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO25 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO26 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO27 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO28 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO29 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO30 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO31 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO32 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO33 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO34 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO35 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO36 0 &GPIO_PORT PIN_NUMBER 0>;
    };
{% if cookiecutter.zest_full_size %}
    sixtron_connector_2: sixtron-connector-2 {
        compatible = "sixtron-bus";
        #gpio-cells = <2>;
        gpio-map-mask = <0xffffffff 0xffffffc0>;
        gpio-map-pass-thru = <0 0x3f>;
        gpio-map = <CAN_RX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <CAN_TX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <I2C_SCL 0 &GPIO_PORT PIN_NUMBER 0>,
                   <I2C_SDA 0 &GPIO_PORT PIN_NUMBER 0>,
                   <UART_RX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <UART_TX 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_MOSI 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_MISO 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_SCK 0 &GPIO_PORT PIN_NUMBER 0>,
                   <SPI_SS 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <PWM3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ICAPT 0 &GPIO_PORT PIN_NUMBER 0>,
                   <WKUP 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO4 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC1 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC2 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC3 0 &GPIO_PORT PIN_NUMBER 0>,
                   <ADC4 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DAC 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO5 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO6 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO7 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO8 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO9 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO10 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO11 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO12 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO13 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO14 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO15 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO16 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO17 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO18 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO19 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO20 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO21 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO22 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO23 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO24 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO25 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO26 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO27 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO28 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO29 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO30 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO31 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO32 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO33 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO34 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO35 0 &GPIO_PORT PIN_NUMBER 0>,
                   <DIO36 0 &GPIO_PORT PIN_NUMBER 0>;
    };
{% endif %}
};

//sixtron_connector_1_can: &fdcan3 {};
//sixtron_connector_1_i2c: &i2c3 {};
//sixtron_connector_1_uart: &usart2 {};
//sixtron_connector_1_spi: &spi1 {};
//sixtron_connector_1_pwm: &timer1 {};
//sixtron_connector_1_adc: &adc1 {};
//sixtron_connector_1_dac: &dac1 {};
{% if cookiecutter.zest_full_size %}
//sixtron_connector_2_can: &fdcan3 {};
//sixtron_connector_2_i2c: &i2c3 {};
//sixtron_connector_2_uart: &usart2 {};
//sixtron_connector_2_spi: &spi1 {};
//sixtron_connector_2_pwm: &timer1 {};
//sixtron_connector_2_adc: &adc1 {};
//sixtron_connector_2_dac: &dac1 {};
{% endif %}
//sixtron_can: &sixtron_connector_1_can {};
//sixtron_i2c: &sixtron_connector_1_i2c {};
//sixtron_uart: &sixtron_connector_1_uart {};
//sixtron_spi: &sixtron_connector_1_spi {};
//sixtron_pwm: &sixtron_connector_1_pwm {};
//sixtron_adc: &sixtron_connector_1_adc {};
//sixtron_dac: &sixtron_connector_1_dac {};
